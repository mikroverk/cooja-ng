## tools/zephyr-boards/boards/ti/cc1312r7_lp/board.yml
```yaml
board:
  name: cc1312r7_lp
  full_name: CC1312R7 LaunchPad (csim out-of-tree)
  vendor: ti
  socs:
  - name: cc1352r7
```
